# Keil uVision project demo_zuolan.uvproj, settings and files
target zuolan (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo_zuolan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\user
  group user
    ./: STARTUP.A51
    ./user/: main.c
  group driver
    ./driver/: key.c led.c seg.c ds1302.c iic.c onewire.c ul.c uart.c init.c
